# Keil uVision project nrf_ble_remote.uvprojx, settings and files
target nrf52810_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x30000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") CLOCK(64000000) ELITTLE
  output: nrf52810_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: DEBUG APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52832 FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\config;..\app;..\bsp;..\ble_srv\my_cus_srv;..\ble_srv\nrf_ble_srv\ble_bas;..\ble_srv\nrf_ble_srv\ble_dis;..\nrf_ble\ble_advertising;..\nrf_ble\ble_link_ctx_manager;..\nrf_ble\common;..\nrf_ble\nrf_ble_gatt;..\nrf_ble\nrf_ble_qwr;..\nrf_ble\peer_manager;..\nrf_drv\legacy;..\nrf_drv\nrfx\drivers\include;..\nrf_drv\nrfx\soc;..\nrf_drv\nrfx\hal;..\nrf_drv\nrfx;..\nrf_drv;..\nrf_lib\atomic;..\nrf_lib\atomic_fifo;..\nrf_lib\atomic_flags;..\nrf_lib\balloc;..\nrf_lib\button;..\nrf_lib\crc16;..\nrf_lib\delay;..\nrf_lib\experimental_section_vars;..\nrf_lib\fds;..\nrf_lib\fprintf;..\nrf_lib\fstorage;..\nrf_lib\hardfault;..\nrf_lib\memobj;..\nrf_lib\mutex;..\nrf_lib\pwr_mgmt;..\nrf_lib\ringbuf;..\nrf_lib\scheduler;..\nrf_lib\sensorsim;..\nrf_lib\sortlist;..\nrf_lib\strerror;..\nrf_lib\timer;..\nrf_lib\util;..\nrf_log;..\nrf_log\src;..\nrf_sfd\common;..\nrf_sfd\s112\headers;..\nrf_sfd\s112\headers\nrf52;..\segger_rtt
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52832 FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DDEVELOP_IN_NRF52832,-DFLOAT_ABI_SOFT,-DNRF52810_XXAA,-DNRF52_PAN_74,-DNRFX_COREDEP_DELAY_US_LOOP_CYCLES=3,-DNRF_SD_BLE_API_VERSION=7,-DS112,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_link_ctx_manager;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s112\headers;..\..\..\..\..\..\components\softdevice\s112\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x17000
  memory RVCT9: RAM 0x20001a50 size 0xe5b0
  link misc: --diag_suppress 6330
  group app
    ../app/: main.c
    ../config/: sdk_config.h
  group bsp
    ../bsp/: battery.c button.c
  group nrf_ble
    ../nrf_ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../nrf_ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../nrf_ble/ble_advertising/: ble_advertising.c
    ../nrf_ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../nrf_ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../nrf_ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group ble_srv
    ../ble_srv/nrf_ble_srv/ble_bas/: ble_bas.c
    ../ble_srv/nrf_ble_srv/ble_dis/: ble_dis.c
    ../ble_srv/my_cus_srv/: ble_rcs.c
  group nrf_drv
    ../nrf_drv/legacy/: nrf_drv_clock.c
    ../nrf_drv/nrfx/soc/: nrfx_atomic.c
    ../nrf_drv/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_saadc.c
    ../nrf_drv/nrfx/drivers/src/prs/: nrfx_prs.c
  group nrf_lib
    ../nrf_lib/button/: app_button.c
    ../nrf_lib/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../nrf_lib/scheduler/: app_scheduler.c
    ../nrf_lib/timer/: app_timer2.c drv_rtc.c
    ../nrf_lib/crc16/: crc16.c
    ../nrf_lib/fds/: fds.c
    ../nrf_lib/hardfault/: hardfault_implementation.c
    ../nrf_lib/atomic_fifo/: nrf_atfifo.c
    ../nrf_lib/atomic_flags/: nrf_atflags.c
    ../nrf_lib/atomic/: nrf_atomic.c
    ../nrf_lib/balloc/: nrf_balloc.c
    ../nrf_lib/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nrf_lib/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../nrf_lib/memobj/: nrf_memobj.c
    ../nrf_lib/pwr_mgmt/: nrf_pwr_mgmt.c
    ../nrf_lib/ringbuf/: nrf_ringbuf.c
    ../nrf_lib/experimental_section_vars/: nrf_section_iter.c
    ../nrf_lib/sortlist/: nrf_sortlist.c
    ../nrf_lib/strerror/: nrf_strerror.c
    ../nrf_lib/sensorsim/: sensorsim.c
  group nrf_log
    ../nrf_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group segger_rtt
    ../segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nrf_sfd
    ../nrf_sfd/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s112_nrf52_7.2.0_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: as above
  output: s112_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x17000
  memory RVCT9: RAM 0x20001a40 size 0x45c0
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:Startup 8.35.0, Device:Startup 8.38.0, Device:StartupConfig 8.38.0
